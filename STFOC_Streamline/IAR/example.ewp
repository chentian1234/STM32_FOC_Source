# IAR project example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\CMSIS\CoreSupport; ..\CMSIS; ..\FWLIB\inc; $PROJ_DIR$; ..\MC\INC; ..\USER
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: example.hex
  ILINK.IlinkOutputFile: example.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  group CMSIS
    ../CMSIS/CoreSupport/: core_cm3.c core_cm3.h
    ../CMSIS/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB/INC
    ../FWLIB/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group FWLIB/SRC
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MC/INC
    ../MC/INC/: MC_Clarke_Park.h MC_const.h MC_Control_Param.h MC_Display.h MC_encoder_param.h MC_FOC_Drive.h MC_FOC_Methods.h MC_Globals.h MC_hall_prm.h MC_Keys.h MC_MotorControl_Layer.h MC_PID_regulators.h MC_PMSM_motor_param.h MC_pwm_1shunt_prm.h MC_pwm_3shunt_prm.h MC_pwm_ics_prm.h MC_State_Observer.h MC_State_Observer_Interface.h MC_State_Observer_param.h MC_type.h stm32f10x_encoder.h stm32f10x_hall.h stm32f10x_lcd.h stm32f10x_MCconf.h stm32f10x_MCdac.h stm32f10x_MClib.h stm32f10x_svpwm_1shunt.h stm32f10x_svpwm_3shunt.h stm32f10x_svpwm_ics.h stm32f10x_Timebase.h
  group MC/SRC
    ../MC/SRC/: MC_Clarke_Park.c MC_FOC_Drive.c MC_Globals.c MC_Keys.c MC_MotorControl_Layer.c MC_PID_regulators.c stm32f10x_encoder.c stm32f10x_svpwm_3shunt.c stm32f10x_Timebase.c
  group USER
    ../USER/: includes.h led.c main.c stm32f10x_it.c uart.c UartProcess.c
